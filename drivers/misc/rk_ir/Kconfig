## drivers/misc/rk_ir/Kconfig
```kconfig
#
# RK_IR devices
#

menuconfig RK_IR
	tristate "ITC RK3288 IR support"
	default n
	help
	  This option enables support for RK3288 IR
```
